# Keil uVision project USBD_HID_Keyboard.uvprojx, settings and files
target USBD_HID_Keyboard (6210000::V6.21::ARMCLANG)
  device: M487JIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.24
  cpu: IRAM(0x20000000,0x28000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: USBD_HID_Keyboard
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: CFG_TUD_ENABLED, CFG_TUSB_MCU = OPT_MCU_M487, TU_BYTE_ORDER = TU_LITTLE_ENDIAN,
  c include: .\;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\tinyusb-master\src;..\..\..\..\ThirdParty\tinyusb-master\examples\device\hid_multiple_interface\src;..\..\..\..\ThirdParty\tinyusb-master\src\common;..\..\..\..\ThirdParty\tinyusb-master\hw;..\..\..\..\ThirdParty\tinyusb-master\src\class\hid
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group User
    ../: main.c
    ../../../../ThirdParty/tinyusb-master/src/portable/nuvoton/M487/: dcd_M487.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c sys.c clk.c uart.c gpio.c
  group tinyusb
    ../../../../ThirdParty/tinyusb-master/src/device/: usbd.c usbd_control.c
    ../../../../ThirdParty/tinyusb-master/src/: tusb.c
    ../../../../ThirdParty/tinyusb-master/src/common/: tusb_fifo.c
    ../../../../ThirdParty/tinyusb-master/src/class/hid/: hid_device.c
    ../../../../ThirdParty/tinyusb-master/examples/device/hid_multiple_interface/src/: usb_descriptors.c
